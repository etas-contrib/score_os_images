# This was autogenerated! Do not modify
SUMMARY = "simple UEFI boot manager - EFI binaries"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "systemd"
HOMEPAGE = "https://systemd.io"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/systemd-boot-efi_257.13-1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/systemd-boot-efi_257.13-1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2c4b24133b4cc546358e8338d728ebef"
SRC_URI[deb0.sha1sum] = "c3f9e935e382dc5d6ab1db2a61e1b0ab94fed357"
SRC_URI[deb0.sha256sum] = "390ecdcef9bbb753f51bb6d8f696bdae2f1dbedde7239c49ccb2512f137a8933"
SRC_URI[deb0.sha512sum] = "6ce4620124ccc215131d3c10e37a5595bb9db11009ed45d1b304e448c22687def548bee5ac2385cbafc438f9a1763cab1d96aab03bc7557d32db97919ee5158f"
SRC_URI[deb1.md5sum] = "b98b0edbdba678b7979cfefb26410fcd"
SRC_URI[deb1.sha1sum] = "da0023d6c8fd04220dd9cbd6bfb69cc81082994f"
SRC_URI[deb1.sha256sum] = "0e4529d9a72b35c31f34151ef8a0df20f322cfef679f4f5439394e60505b91a2"
SRC_URI[deb1.sha512sum] = "a5f3b7bf5f818d765dbfd55e362d52e89478f8ad173fa3b7330d9e18dfc2cb788ef4d61f41a2f09a6b07a20b9b6a56e772e2d7b928c1a4ccbd2363e5d93d1851"


